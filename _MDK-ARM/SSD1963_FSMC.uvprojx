# Keil uVision project SSD1963_FSMC.uvprojx, settings and files
target SSD1963_FSMC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: SSD1963_FSMC
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=4 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;                       ../Drivers/STM32F4xx_HAL_Driver/Inc;                       ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                       ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                       ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c stm32f4xx_hal_sram.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rtc_ex.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_rtc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_spi.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_i2c.c
  group Application/User
    ../Src/: stm32f4xx_hal_msp.c main.c stm32f4xx_it.c ssd1963_fsmc.c xpt2046.c font_arial_16x16_bold.c font_arial_16x16_italic.c font_arial_16x16_normal.c font_arial_16x24_round.c font_arial_32x50_num.c font_barcode_post_40x20_num.c font_battery_24x48.c font_calibri_32x48_bold_num.c font_default_8x12.c font_default_16x16.c font_dingbats1_32x24.c font_franklingothic_16x16.c font_hallfetica_16x16.c font_inconsola_24x32.c font_matrix_16x22.c font_matrix_16x22_slash.c font_matrix_24x29_num.c font_matrix_32x50_num.c font_myke_8x9.c font_nadianne_16x16.c font_ocr_16x24.c font_retro_8x16.c font_retro_16x32.c font_barcode_rm4scc_16x16.c font_segment_eighteen_32x52.c font_segment_seven_32x50_num.c font_segment_seven_64x100_num.c font_segment_seven_96x144_num.c font_segment_sixteen_16x24.c font_segment_sixteen_24x36.c font_segment_sixteen_32x48.c font_segment_sixteen_32x50.c font_segment_sixteen_40x60.c font_segment_sixteen_48x72_num.c font_segment_sixteen_64x96_num.c font_segment_sixteen_96x144_num.c font_segment_sixteen_128x192_num.c font_sinclair_8x8.c font_sinclair_8x8_inverted.c font_sinclair_16x16.c font_sinclair_16x16_inverted.c font_swiss_16x16.c font_symbols_16x16.c font_symbols_16x32_1.c font_symbols_16x32_2.c font_symbols_32x32.c font_tiny_8x8.c font_ubuntu_24x32.c font_ubuntu_24x32_bold.c
software components: CMSIS:CORE 5.0.2
